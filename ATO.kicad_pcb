# Repository whendonkiesfly/OSH-ATO

File README.md:

# OSHOTA

An open source auto top off pump controller on the cheap.

This works with a single float switch (closed when the water level is high) and a 5-12v pump.
The pump will be activated at some time after the water level drops too low. This amount of time is
determined by the value of the capacitor and its self discharge rate. The pump will be deactivated after
the water level is high again.

## KiCad design ATO.kicad_pcb

Parts:
C1: C; C_Disc_D9.0mm_W2.5mm_P5.00mm
C2: CP; C_Disc_D9.0mm_W2.5mm_P5.00mm
D1: LED_Y; LED_D5.0mm
D2: LED_G; LED_D5.0mm
D3: LED_R; LED_D5.0mm
J1: Pump Out; TerminalBlock_bornier-2_P5.08mm
J2: Switch; TerminalBlock_bornier-2_P5.08mm
J3: Power; TerminalBlock_bornier-2_P5.08mm
Q1: NFET; TO-251-3-1EP_Horizontal_TabDown
Q2, Q4: PFET; TO-92_HandSolder
Q3: NFET; TO-92_HandSolder
R1, R3, R5, R6: R1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: R100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: R75; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: Reset; SW_PUSH_6mm_H13mm
SW2: Fill; SW_PUSH_6mm_H13mm

Connections:
GND: C1.2, C2.2, D3.1 (K), J2.1, J3.2, Q1.3 (S), Q3.1 (D), R2.2, SW1.1 (A), SW2.2 (B)
unnamed: C1.1, Q2.2 (G), R4.1, R5.2
unnamed: C2.1, J1.2, J3.1, Q4.1 (S), R1.1, R3.2, R6.1
unnamed: D1.1 (K), J1.1, Q1.2 (D), Q1.4 (D)
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), J2.2, SW1.2 (B)
unnamed: D2.2 (A), Q2.1 (S), Q4.2 (G), R3.1
unnamed: D3.2 (A), R6.2
unnamed: Q1.1 (G), Q2.3 (D), Q3.2 (G), R2.1
unnamed: Q3.3 (S), R4.2, SW2.1 (A)
unnamed: Q4.3 (D), R5.1

Board: 2 copper layers, 42.2 x 43.2 mm, 20 parts (0 on the bottom side), 11 nets.

## Commit log

2021-07-29 Added file storing circuit simulator link
2021-07-31 Added cap on power input and other tweaks.
